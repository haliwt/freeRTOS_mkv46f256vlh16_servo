# IAR project pwm.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV44F128xxx16 NXP MKV44F128xxx16
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MKV46F256VLL16; TWR_KV46F150M; TOWER
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../..; ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../devices/MKV46F16; ../../../../../devices/MKV46F16/utilities/str; ../../../../../devices/MKV46F16/utilities/debug_console; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/lists; ..\utilities\debug_console; ..\drivers; ..\startup; ..\CMSIS\Include; ..\utilities\str; ..\components\serial_manager; ..\components\uart; ..\hardware\led; ..\hardware\pwm; ..\user; ..\hardware\hall; ..\hardware\key; ..\fsl_drivers; ..\hardware\adc; ..\freertos\FreeRTOS\portable\IAR\ARM_CM4F; ..\freertos\FreeRTOS\portable\IAR; ..\freertos\FreeRTOS\portable\MemMang; ..\freertos\include\private; ..\freertos; ..\freertos\include; ..\hardware\pollingusart; ..\hardware\bldc; ..\hardware\output; ..\hardware\input; ..\hardware\usart_rb_edma; ..\components\timer; $PROJ_DIR$
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: pwm.hex
  ILINK.IlinkOutputFile: pwm.out
  ILINK.IlinkIcfFile: MKV46F256xxx16_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MKV46F256xxx16 NXP MKV46F256xxx16
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; CPU_MKV46F256VLL16; TWR_KV46F150M; TOWER
  ICCARM.CCIncludePath2: ..; ../../..; ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../devices/MKV46F16/drivers; ../../../../../devices/MKV46F16/drivers; ../../../../../devices/MKV46F16/drivers; ../../../../../devices/MKV46F16/drivers; ../../../../../devices/MKV46F16/drivers; ../../../../../devices/MKV46F16; ../../../../../devices/MKV46F16/utilities/str; ../../../../../devices/MKV46F16/utilities/debug_console; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/serial_manager; ../../../../../devices/MKV46F16/drivers; ../../../../../components/lists; ../../../../../devices/MKV46F16/drivers; ../../../../../devices/MKV46F16/drivers
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group amazon-freertos/freertos
    ../freertos/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group amazon-freertos/freertos/portable
    ../freertos/FreeRTOS/portable/MemMang/: heap_4.c
    ../freertos/FreeRTOS/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group amazon-freertos/include
    ../freertos/include/private/: deprecated_definitions.h list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h stack_macros.h threading_alt.h
    ../freertos/include/: event_groups.h FreeRTOS.h freertos_tasks_c_additions.h message_buffer.h queue.h semphr.h stream_buffer.h task.h timers.h
  group board
    ../: board.c clock_config.c pin_mux.c
  group CMSIS
    ../CMSIS/Include/: core_cm4.h
  group component/serial_manager
    ../components/serial_manager/: serial_manager.c serial_port_uart.c
  group component/timer
    ../components/timer/: lptmr_adapter.c timer.h
  group component/uart
    ../components/uart/: uart_adapter.c
  group doc
    ../: readme.txt
  group fsl_drivers
    ../fsl_drivers/: fsl_aoi.c fsl_cadc.c fsl_clock.c fsl_cmp.c fsl_common.c fsl_crc.c fsl_dac.c fsl_dmamux.c fsl_dspi.c fsl_dspi_edma.c fsl_edma.c fsl_enc.c fsl_ewm.c fsl_flexcan.c fsl_flexcan_edma.c fsl_ftfx_cache.c fsl_ftfx_controller.c fsl_ftfx_flash.c fsl_ftfx_flexnvm.c fsl_gpio.c fsl_i2c.c fsl_i2c_edma.c fsl_llwu.c fsl_lptmr.c fsl_pdb.c fsl_pit.c fsl_pmc.c fsl_pwm.c fsl_rcm.c fsl_sim.c fsl_smc.c fsl_uart.c fsl_uart_edma.c fsl_wdog.c fsl_xbara.c fsl_xbarb.c
  group hardware
    ../hardware/adc/: adc.c
    ../hardware/bldc/: bldc.c
    ../hardware/input/: input.c
    ../hardware/key/: key.c
    ../hardware/led/: led.c
    ../hardware/output/: output.c
    ../hardware/pollingusart/: pollingusart.c
    ../hardware/usart_rb_edma/: usart_edma_rb.c
  group source
    ../: main.c
  group startup
    ../startup/: startup_MKV46F16.s system_MKV46F16.c
  group utilities
    ../utilities/: fsl_assert.c
    ../utilities/debug_console/: fsl_debug_console.c
    ../utilities/str/: fsl_str.c
